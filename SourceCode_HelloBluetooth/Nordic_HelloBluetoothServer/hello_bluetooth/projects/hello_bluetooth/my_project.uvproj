# Keil uVision project my_project.uvproj, settings and files
target nRF8200 (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: hello_bluetooth_nrf8200 +hex
  BeforeMake: nrfgostudio\preBuild.bat my_project.xml
  c flags: Optimize=9
  c define: ASSERT_ENABLE=NO_TRACES DEBUG_ENABLE=NO_TRACES NOBONDING
  c include: ..\;.\;..\..\lib;..\..\hal\common;..\..\hal\nRF8200;..\..\compiler\c51;..\..\aci_codec;..\..\services;nrfgostudio;.\source\nRF8200;.\source
  link misc: REMOVEUNUSED
  group application
    ./source/nRF8200/: main.c system.c
    ./source/: assertions.c error_handling.c my_application.c
    ../../hal/nRF8200/: STARTUP.A51
    ./nrfgostudio/: services.c
  group lib
    ../../lib/: lib_aci.c lib_mem.c lib_traces.c
    ../../aci_codec/: acilib.c
  group hal
    ../../hal/nRF8200/: hal_aci_tl.c hal_power.c hal_uart.c
